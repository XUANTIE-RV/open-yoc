# Keil uVision project sig_mesh.uvprojx, settings and files
target ARMCM0 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: sig_mesh
  AfterMake: ..\..\..\..\tools\le501x\after_build.bat @L ..\..\..\.. dev\soc\arm_cm\le501x\bin\fw_with_mesh.hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99 -O2 --wchar32
  c include: ..\..\..\module\crc;..\..\..\module\debug;..\..\..\module\debug\RTT;..\..\..\module\static_buffer;..\..\..\module\tinyfs;..\..\..\module\tinycrypt\lib\include;..\..\..\module\ble;..\..\..\module\ble\prf;..\..\..\module\common;..\..\..\module\adpcm;..\..\..\peripheral\qspi_flash;..\..\..\peripheral\cache;..\..\..\peripheral\calc;..\..\..\peripheral\uart;..\..\..\peripheral\trng;..\..\..\peripheral\ecc;..\..\..\peripheral\crypt;..\..\..\peripheral\iwdt;..\..\..\peripheral\adc;..\..\..\peripheral\timer;..\..\..\peripheral\rtc;..\..\..\peripheral\dma;..\..\..\peripheral\pdm;..\..\..\peripheral\spi;..\..\..\peripheral;..\..\..\soc\arm_cm;..\..\..\soc\arm_cm\cmsis;..\..\..\soc\arm_cm\le501x;..\..\..\soc\arm_cm\le501x\integration;..\..\..\soc;..\..\..;..;
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\soc\arm_cm\le501x\compiler\armcc\link_script.txt
  link misc: --datacompressor=off
  group app
    ../: main.c sig_light_cfg.c sig_mesh_ctl.c
  group module
    ../../../module/debug/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../../../module/adpcm/: adpcm.c
    ../../../module/common/: common.c
    ../../../module/crc/: crc16.c
    ../../../module/tinycrypt/lib/source/: ecc.c ecc_dsa.c ecc_platform_specific.c sha256.c utils.c
    ../../../module/static_buffer/: fifo.c linked_buffer.c
    ../../../module/debug/: log.c ls_dbg.c
    ../../../module/debug/arm_cm/armcc/: ls_dbg_asm.S
    ../../../module/tinyfs/: tinyfs.c tinyfs_nvm.c tinyfs_write_cache.c
  group peripheral
    ../../../peripheral/calc/: calc_div.c
    ../../../peripheral/dma/: dma.c
    ../../../peripheral/pdm/: dmic.c
    ../../../peripheral/adc/: lsadc.c
    ../../../peripheral/cache/: lscache.c
    ../../../peripheral/crypt/: lscrypt.c
    ../../../peripheral/ecc/: lsecc.c
    ../../../peripheral/spi/: lsi2s.c lsspi.c
    ../../../peripheral/iwdt/: lsiwdt.c
    ../../../peripheral/qspi_flash/: lsqspi.c spi_flash.c
    ../../../peripheral/timer/: lstimer.c
    ../../../peripheral/trng/: lstrng.c
    ../../../peripheral/rtc/: rtc.c
    ../../../peripheral/uart/: smartcard.c uart.c
  group soc
    ../../../soc/arm_cm/le501x/integration/: calc_acc.c io_config.c lscache_msp.c lsqspi_msp.c modem_rf_le501x.c rtc_param.c spi_msp.c uart_msp.c
    ../../../soc/arm_cm/le501x/: cpu.c platform.c sleep.c stack_var.c sys_stat.c
    ../../../soc/arm_cm/le501x/compiler/armcc/: delay_asm.S sleep_asm.S startup.S svcall_asm.S
    ../../../soc/: flash_svcall.c
    ../../../soc/arm_cm/le501x/bin/: libmesh.o
    ../../../soc/arm_cm/: svcall.c swint_handler.c systick.c
