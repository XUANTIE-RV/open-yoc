/*
 * Copyright (C) 2017 C-SKY Microsystems Co., Ltd. All rights reserved.
 *
 * Licensed under the Apache License, Version 2.0 (the "License");
 * you may not use this file except in compliance with the License.
 * You may obtain a copy of the License at
 *
 *   http://www.apache.org/licenses/LICENSE-2.0
 *
 * Unless required by applicable law or agreed to in writing, software
 * distributed under the License is distributed on an "AS IS" BASIS,
 * WITHOUT WARRANTIES OR CONDITIONS OF ANY KIND, either express or implied.
 * See the License for the specific language governing permissions and
 * limitations under the License.
 */

#include <string.h>
#include <stdint.h>
#include "mbedtls/aes.h"
#include "mbedtls/sha1.h"
#include "mbedtls/sha256.h"
#include "mbedtls/rsa.h"

#include "tee_debug.h"
#include "tee_test.h"

// unsigned char memory_buf[1024 * 5];
// extern void mbedtls_memory_buffer_alloc_init(unsigned char *buf, size_t len);

const uint8_t n[] = {
    0xe9, 0xd3, 0xa9, 0x32, 0x29, 0x18, 0xcf, 0x7d, 0xc3, 0x0c, 0x0b, 0xc8, 0x70, 0xf5, 0x3f, 0x06,
    0xbc, 0xd2, 0x40, 0x27, 0x8f, 0x9e, 0xce, 0x0a, 0x3e, 0x3f, 0xac, 0x2b, 0xd4, 0x2a, 0x5a, 0x16,
    0x66, 0x0b, 0x5e, 0x60, 0xdc, 0x8a, 0x0e, 0xdd, 0x4d, 0xae, 0x65, 0xbf, 0x32, 0xf1, 0x7b, 0xe8,
    0x9f, 0xb6, 0xfc, 0x05, 0xf4, 0x27, 0x87, 0x2d, 0xc6, 0x86, 0xd9, 0x45, 0xea, 0xf1, 0x7d, 0xab,
    0xc3, 0xb8, 0x2d, 0x13, 0x92, 0x96, 0x6d, 0x6b, 0xf3, 0xd7, 0x54, 0x15, 0xb0, 0x54, 0xb5, 0x6b,
    0x42, 0x8b, 0x27, 0x62, 0xe8, 0x31, 0xaf, 0x33, 0xe0, 0x7a, 0xd0, 0x8a, 0x6a, 0xbe, 0xae, 0x97,
    0xc1, 0xdb, 0xb4, 0x8a, 0xa2, 0x87, 0xd0, 0x0a, 0xae, 0x6a, 0xce, 0xb8, 0xe7, 0xed, 0x51, 0x7c,
    0xc7, 0x14, 0xff, 0x5d, 0xa6, 0x95, 0x4a, 0x24, 0xb8, 0x9c, 0x42, 0x44, 0x84, 0xd2, 0xba, 0x85,
    0x8e, 0x08, 0x32, 0x2c, 0x4f, 0xd6, 0xdc, 0x70, 0x99, 0x38, 0xe6, 0xb6, 0x10, 0x76, 0x88, 0x0a,
    0xe5, 0xf3, 0x42, 0xc1, 0x2d, 0x0d, 0xff, 0x2c, 0x91, 0x2e, 0x9c, 0xa8, 0xa6, 0xe4, 0xed, 0xd3,
    0x0a, 0x4a, 0x09, 0xea, 0x4f, 0xd1, 0xc1, 0x6c, 0xdf, 0x7d, 0x90, 0xaf, 0x68, 0xa8, 0x26, 0x92,
    0x91, 0x0b, 0x00, 0x6f, 0xe6, 0x1f, 0x63, 0xdd, 0x0b, 0x4f, 0x35, 0xae, 0x02, 0x81, 0x6e, 0x26,
    0x5e, 0x35, 0x02, 0x04, 0x85, 0x0c, 0x3d, 0xe9, 0x23, 0xd3, 0x5a, 0x33, 0xdb, 0x79, 0x21, 0x62,
    0xa1, 0xe8, 0x86, 0x74, 0x64, 0xc8, 0xe5, 0xb0, 0xb1, 0xe0, 0xa0, 0x3b, 0x95, 0x04, 0x02, 0x0f,
    0x46, 0xe5, 0xf0, 0xda, 0x30, 0xbc, 0xbe, 0xfe, 0x22, 0x0b, 0x52, 0xea, 0x9c, 0x65, 0xc9, 0x5c,
    0xac, 0xa6, 0xd1, 0x4d, 0xac, 0x6f, 0xe7, 0xfe, 0xbd, 0x24, 0x88, 0x8e, 0x92, 0xe4, 0x15, 0xb5
};

const uint8_t e[] = {
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x01
};
const uint8_t d[] = {
    0x84, 0xcd, 0x88, 0x5d, 0x4a, 0xe6, 0x22, 0x82, 0xc5, 0x12, 0xc4, 0x66, 0x75, 0x71, 0x74, 0xf8,
    0x78, 0xa9, 0xd9, 0x72, 0x1e, 0xaa, 0x0d, 0x4f, 0xd8, 0x07, 0x05, 0xdc, 0x66, 0xc6, 0x1f, 0x20,
    0x75, 0x98, 0xa3, 0x63, 0xd4, 0x1e, 0x3d, 0x4f, 0x07, 0xdd, 0xb3, 0x40, 0x22, 0xc8, 0xf0, 0x9d,
    0x30, 0x89, 0x17, 0x1e, 0xb2, 0x8a, 0xf8, 0xc5, 0xd0, 0xe9, 0xa9, 0xe1, 0x82, 0x0c, 0xe2, 0x59,
    0x79, 0xf1, 0xd2, 0xf8, 0x38, 0xdb, 0x63, 0x0e, 0x5b, 0x11, 0xc3, 0x5a, 0x06, 0x2a, 0x36, 0x57,
    0xd3, 0x15, 0x81, 0xab, 0x35, 0x41, 0x72, 0xc6, 0xbe, 0x0a, 0x43, 0x03, 0x3a, 0x99, 0x4e, 0x44,
    0x37, 0x00, 0x77, 0xcb, 0xfd, 0x7f, 0xb1, 0x73, 0x3f, 0x98, 0xbe, 0x0c, 0x5a, 0xfd, 0x78, 0xb8,
    0xab, 0xc1, 0x8b, 0x40, 0x3f, 0x6a, 0xaf, 0x0f, 0xa8, 0x22, 0x67, 0xa8, 0xce, 0xdf, 0x78, 0xbb,
    0x67, 0xdf, 0x6f, 0x57, 0x8f, 0xd1, 0xfd, 0x7a, 0x44, 0xee, 0x32, 0x83, 0x63, 0xef, 0x56, 0x44,
    0xbc, 0x0d, 0x90, 0x66, 0x6f, 0x20, 0x02, 0x55, 0xd5, 0xb4, 0x36, 0xf9, 0x40, 0xdc, 0x27, 0x35,
    0x45, 0x9c, 0x01, 0x12, 0x50, 0xaa, 0xf0, 0xca, 0x82, 0xfe, 0xf1, 0x1f, 0x61, 0x28, 0xd6, 0x51,
    0x53, 0x44, 0xf4, 0x6c, 0xa4, 0x37, 0xda, 0xf8, 0x0c, 0x35, 0x31, 0x23, 0xd6, 0x98, 0x99, 0xf8,
    0xeb, 0xea, 0xdb, 0xfc, 0x12, 0x6f, 0x9b, 0x3b, 0xee, 0xc4, 0x0b, 0x80, 0x3c, 0x34, 0x9c, 0x87,
    0x95, 0x76, 0xbc, 0x28, 0xdd, 0x50, 0xeb, 0x20, 0xf3, 0x06, 0xe6, 0xf4, 0x79, 0x87, 0xa5, 0x31,
    0x4c, 0xbf, 0xa5, 0x33, 0x29, 0xfd, 0x36, 0x64, 0x7e, 0xc1, 0x33, 0x8c, 0x65, 0xbb, 0x34, 0x9e,
    0xab, 0x2f, 0x75, 0x3e, 0xd6, 0xc9, 0xdc, 0xb2, 0x64, 0x9a, 0x64, 0xc5, 0x95, 0xe8, 0xa4, 0x01
};

#define PT_LEN  24
#define RSA_PT  "\xAA\xBB\xCC\x03\x02\x01\x00\xFF\xFF\xFF\xFF\xFF" \
    "\x11\x22\x33\x0A\x0B\x0C\xCC\xDD\xDD\xDD\xDD\xDD"

#define KEY_LEN 256

int mbedtls_rsa2048_self_test(int verbose)
{
    int ret = 0;
    size_t len;
    mbedtls_rsa_context rsa;
    unsigned char rsa_plaintext[PT_LEN];
    unsigned char rsa_decrypted[PT_LEN];
    unsigned char rsa_ciphertext[KEY_LEN];
    unsigned char sha256sum[32];

    TEE_LOGI("mbedtls RSA2048 test\n");
    mbedtls_rsa_init(&rsa, MBEDTLS_RSA_PKCS_V15, 0);

    rsa.len = 256;
    MBEDTLS_MPI_CHK(mbedtls_mpi_read_binary(&rsa.N , n, sizeof(n)));
    MBEDTLS_MPI_CHK(mbedtls_mpi_read_binary(&rsa.E , e, sizeof(e)));
    MBEDTLS_MPI_CHK(mbedtls_mpi_read_binary(&rsa.D , d, sizeof(d)));

    if (verbose != 0) {
        TEE_LOGI("  PKCS#1 encryption : ");
    }

    memcpy(rsa_plaintext, RSA_PT, PT_LEN);

    ret = mbedtls_rsa_pkcs1_encrypt(&rsa, NULL, NULL, MBEDTLS_RSA_PUBLIC, PT_LEN,
                                    rsa_plaintext, rsa_ciphertext);

    if (ret != 0) {
        if (verbose != 0) {
            TEE_LOGE("failed, ret %d\n", ret);
        }

        return (1);
    }

    if (verbose != 0) {
        TEE_LOGI("passed\n  PKCS#1 decryption : ");
    }

    ret = mbedtls_rsa_pkcs1_decrypt(&rsa, NULL, NULL, MBEDTLS_RSA_PRIVATE, &len,
                                    rsa_ciphertext, rsa_decrypted,
                                    sizeof(rsa_decrypted));

    if (ret != 0) {
        if (verbose != 0) {
            TEE_LOGE("failed\n");
        }

        return (1);
    }

    if (memcmp(rsa_decrypted, rsa_plaintext, len) != 0) {
        if (verbose != 0) {
            TEE_LOGE("failed\n");
        }

        return (1);
    }

    if (verbose != 0) {
        TEE_LOGI("passed\n");
    }

#if defined(MBEDTLS_SHA1_C)

    if (verbose != 0) {
        TEE_LOGI("  PKCS#1 data sign  : ");
    }

    mbedtls_sha256(rsa_plaintext, PT_LEN, sha256sum, 0);

    if (mbedtls_rsa_pkcs1_sign(&rsa, NULL, NULL, MBEDTLS_RSA_PRIVATE, MBEDTLS_MD_SHA256, 0,
                               sha256sum, rsa_ciphertext) != 0) {
        if (verbose != 0) {
            TEE_LOGE("failed\n");
        }

        return (1);
    }

    if (verbose != 0) {
        TEE_LOGI("passed\n  PKCS#1 sig. verify: ");
    }

    if (mbedtls_rsa_pkcs1_verify(&rsa, NULL, NULL, MBEDTLS_RSA_PUBLIC, MBEDTLS_MD_SHA256, 0,
                                 sha256sum, rsa_ciphertext) != 0) {
        if (verbose != 0) {
            TEE_LOGE("failed\n");
        }

        return (1);
    }

    if (verbose != 0) {
        TEE_LOGI("passed\n");
    }

#endif /* MBEDTLS_SHA1_C */

    if (verbose != 0) {
        TEE_LOGI("\n");
    }

cleanup:
    mbedtls_rsa_free(&rsa);
    return (ret);
}

void tee_mbedtls_test(void)
{
    TEE_LOGI("Mbedtls TEST\n");
    // mbedtls_memory_buffer_alloc_init(memory_buf, sizeof(memory_buf));
#if (CONFIG_ALGO_AES > 0)
  //  mbedtls_aes_self_test(1);
#endif
#if (CONFIG_ALGO_SHA > 0)
   // mbedtls_sha1_self_test(1);
   // mbedtls_sha256_self_test(1);
#endif
#if (CONFIG_ALGO_RSA > 0)
    // mbedtls_rsa_self_test(1);
    mbedtls_rsa2048_self_test(1);
#endif
}
